# Keil uVision project SPI_INTERRUPT_BME_280_C.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI_INTERRUPT_BME_280_C
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: main.c
  group lib
    ./: GPIO_CONFIG.c RCC_CLOCK_CONFIG.c SPI_MASTER.c TIMER_CONFIG.c USART_CONFIG.c LCD_DRIVER.c
  group include
    ./: GPIO_CONFIG.h RCC_CLOCK_CONFIG.h SPI_MASTER.h TIMER_CONFIG.h USART_CONFIG.h main.h LCD_DRIVER.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
